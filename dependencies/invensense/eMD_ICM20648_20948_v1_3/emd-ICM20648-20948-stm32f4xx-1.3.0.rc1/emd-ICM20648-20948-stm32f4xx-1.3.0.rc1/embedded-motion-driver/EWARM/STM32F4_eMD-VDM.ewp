# IAR project STM32F4_eMD-VDM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_DMP; MPL_LOG_NDEBUG=1; EMPL; MEMS_20648; MEMS_AUGMENTED_SENSORS; MEMS_WEARABLE_DEVICE; EMPL_TARGET_STM32F4
  ICCARM.CCIncludePath2: ..\User\inc; ..\User\src; ..\Peripheral\inc; ..\Peripheral\src; ..\STM32F4xx_StdPeriph_Driver\inc; ..\STM32F4xx_StdPeriph_Driver\src; ..\DeviceSupport\inc; ..\DeviceSupport\inc; ..\core\driver\include; ..\core\driver\stm32l; ..\Mems
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F4_eMD-VDM.srec
  ILINK.IlinkOutputFile: STM32F4-Discovery.out
  ILINK.IlinkIcfFile: stm32f40x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group 20648_driver/common
    ../Mems/common/: inv_mems_drv_hook.c inv_mems_drv_hook.h mltypes.h
  group 20648_driver/dmp3
    ../Mems/dmp3/: inv_mems_interface_mapping.c inv_mems_interface_mapping.h
  group 20648_driver/dmp3a
    ../Mems/dmp3/: dmp3Default_20608D.c dmp3Default_20608D.h dmp3Default_20608D.txt
    ../Mems/dmp3a/: dmp3Default_20648.c dmp3Default_20648.h dmp3Default_20648.txt dmp3Driver.h
  group 20648_driver/drivers/include
    ../Mems/driver/: inv_mems_augmented_sensors.h inv_mems_base_control.h inv_mems_base_control_20609.h inv_mems_base_driver.h inv_mems_base_driver_20609.h inv_mems_data_converter.h inv_mems_defines.h inv_mems_hw_config.h inv_mems_load_firmware.h inv_mems_mpu_fifo_control.h inv_mems_mpu_selftest.h inv_mems_secondary_transport.h inv_mems_slave_compass.h inv_mems_slave_pressure.h inv_mems_transport.h
  group 20648_driver/drivers/source
    ../Mems/driver/: inv_mems_augmented_sensors.c inv_mems_base_control.c inv_mems_base_control_20609.c inv_mems_base_driver.c inv_mems_base_driver_20609.c inv_mems_data_converter.c inv_mems_load_firmware.c inv_mems_mpu_fifo_control.c inv_mems_mpu_selftest.c inv_mems_mpu_selftest_20609.c inv_mems_secondary_transport.c inv_mems_slave_compass.c inv_mems_slave_pressure.c inv_mems_transport.c
  group 20648_driver/invn
    ../Mems/invn/common/: int_types.h invn_assert.h invn_enums.h invn_export.h invn_types.h invn_utils.h ml_math_func.c ml_math_func.h mlmath.c mlmath.h
    ../Mems/: inv_mems.h
  group core/include
    ../core/driver/include/: log.h
  group core/source
    ../core/driver/stm32L/: log_stm32.c
  group DeviceSupport/include
    ../DeviceSupport/inc/: board-st_discovery.h discover_board.h platform_defaults.h stm32f4_discovery.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.h
  group DeviceSupport/source
    ../DeviceSupport/src/: board-st_discovery.c startup_stm32f40x.s stm32f4_discovery.c stm32f4xx_it.c system_stm32f4xx.c
  group Peripheral/include
    ../Peripheral/inc/: gpio.h i2c.h uart.h
  group Peripheral/source
    ../Peripheral/src/: gpio.c i2c.c uart.c
  group STM32F4xx_StdPeriph_Driver/includes
    ../STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group STM32F4xx_StdPeriph_Driver/source
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User/includes
    ../User/inc/: main.h
  group User/source
    ../User/src/: main.c
